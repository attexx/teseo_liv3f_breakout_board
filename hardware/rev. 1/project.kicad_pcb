# Repository attexx/teseo_liv3f_breakout_board

File README.md:

# TESEO-LIV3F Breakout Board

This is a simple circuit board, designed to enable easy testing and evaluation of the STMicroelectronics [TESEO-LIV3F][db4cd872] GNSS module.

  [db4cd872]: https://www.st.com/en/positioning/teseo-liv3f.html "teseo-liv3f"

</img>

</imag>

## KiCad design hardware/rev. 1/project.kicad_pcb

Parts:
C1, C3: 120p; C_0402_1005Metric
C2: 1n; C_0402_1005Metric
C4, C5: 10n; C_0402_1005Metric
C6, C7, C8, C9, C10: 56p; C_0201_0603Metric
C11: 22u; C_0805_2012Metric
J1: Conn_Coaxial; Connector_Coaxial_U.FL_Hirose_U.FL-R-SMT-1_Vertical
J2: Conn_01x10; PinHeader_1x10_P2.54mm_Vertical
J3: Conn_01x10_1; PinHeader_1x10_P2.54mm_Vertical_1
L1: 5n6; L_0402_1005Metric
L2: 27n; L_0402_1005Metric
L3: 10uH 1.4A; Bourns_SRP3020TA_1
R1: 10k; R_0402_1005Metric
R2, R3: DNP; R_0402_1005Metric
R4: 1M; R_0402_1005Metric
R5: 68k; R_0402_1005Metric
R6: 15k; R_0402_1005Metric
U1: BGA725L6; TSNP-6_0.8x0.7mm_P0.4mm_1
U2: B4327; Filter_1411-5_1.4x1.1mm_1
U3: TESEO-LIV3F; TESEO_LIV3F_SMD; MPN TESEO-LIV3F; Digi-Key_PN 497-18163-ND
U4: ST1S12GR; TSOT-23-5

Connections:
+3V3: C11.1, J3.13, L3.2, R5.1
+5V: J3.12, R4.2, U4.4 (VIN)
/1PPS: C8.1, J3.16, U3.4
/ANT_OFF: J2.8, R1.1, U1.6 (PON), U3.13
/RF_IN: C3.1, R3.2, U3.11
/SCL: J3.15, U3.17
/SDA: J3.14, U3.16
/UART_RX: C9.1, J3.17, U3.3
/UART_TX: C10.1, J3.18, U3.2
/VCC: C6.1, J2.3, L2.2, U3.8
/VCC_F: C5.1, J3.19, L2.1
/VCC_IO: J2.4, U3.7
/VCC_RF: C2.2, C7.1, J2.7, U1.2 (VCC), U3.14
/V_BATT: C4.2, J2.5, U3.6
/WAKEUP: J2.6, U3.5
/~RESET: J2.2, U3.9
GND: C2.1, C4.1, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, J1.2 (Ext), J2.1, J2.9, J2.10, J3.11, J3.20, R1.2, R6.2, U1.1 (GND), U1.4 (GNDRF), U2.2 (GND), U2.3 (GND), U2.4 (GND), U3.1, U3.10, U3.12, U4.2 (GND)
unnamed: C1.1, L1.1
unnamed: C1.2, J1.1 (In), R2.2
unnamed: C3.2, U2.5 (AO)
unnamed: L1.2, U1.5 (AI)
unnamed: L3.1, U4.3 (SW)
unnamed: R2.1, R3.1
unnamed: R4.1, U4.1 (EN)
unnamed: R5.2, R6.1, U4.5 (WFB)
unnamed: U1.3 (AO), U2.1 (AI)

Board: 2 copper layers, 19.0 x 26.6 mm, 28 parts (16 on the bottom side), 26 nets.

Other parts of the board:
FID1: Corner_90x0.5

## Commit log

2019-08-27 add .gitignore
2019-08-28 update images
2019-08-28 update title
2019-08-28 add README.md to the hardware folder
2019-08-28 update description
2019-08-28 update pcb layout
2019-08-28 update components list
2019-08-28 upddate .gitignore
2019-08-28 update schematic file
2019-10-24 added rev. 2
